# Keil uVision project cyber_minion.uvprojx, settings and files
target Dev (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cyber_minion
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;..\..\qp\qtools\unity\src;.\tm4c\system;.\CMSIS\Core\Include;.\tm4c
  asm misc: --target=arm-arm-none-eabi
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Deploy
    ./src/: cyber_minion.c cyber_minion.h cyber_minion_runner.c
    ./tm4c/startup/: startup_TM4C123.s
    ./tm4c/system/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h
    ./tm4c/: TM4C123GH6PM.h tm4c_bsp.c tm4c_bsp.h tm4c_bsp_set_sp.h
  group Unit Test
    ./test/unit/: cyber_minion_unit_tests.c
    ./test/unit/mocks/: Mocktm4c_bsp.c Mocktm4c_bsp.h
  group HIL Tests
    ./test/hil/: cyber_minion_hil_tests.c
    ./test/hil/mocks/: Mocktm4c_bsp_set_sp.h Mocktm4c_bsp_set_sp.c
  group CMSIS
    ./CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h
  group Unity
    ./test/framework/src/: unity.c unity.h unity_internals.h
  group CMock
    ../../../cmock/src/: cmock.c cmock.h cmock_internals.h
target Unit Tests (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: cyber_minion
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -DUNIT_TEST
  c include: .\CMSIS\Core\Include;.\test\framework\src;..\..\..\cmock\src;.\tm4c;.\tm4c\system;.\src
  asm misc: --target=arm-arm-none-eabi
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target HIL Tests (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: as above
  output: cyber_minion
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: -DHIL_TEST
  c include: .\CMSIS\Core\Include;.\test\framework\src;.\tm4c;.\tm4c\system;.\src;..\..\..\cmock\src;.\test\hil\mocks
  asm misc: --target=arm-arm-none-eabi
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
